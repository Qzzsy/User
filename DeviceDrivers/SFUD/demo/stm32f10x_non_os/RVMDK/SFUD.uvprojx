# Keil uVision project SFUD.uvprojx, settings and files
target stm32f103xE (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SFUD
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,USE_FULL_ASSERT
  c misc: --C99
  c include: ..\app\inc;..\components\others;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS_RVMDK\CM3\CoreSupport;..\Libraries\CMSIS_RVMDK\CM3\DeviceSupport\ST\STM32F10x;..\components\sfud\inc;..\..\..\sfud\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../APP/src/: app.c stm32f10x_it.c
    ../app/inc/: stm32f10x_conf.h
  group bsp
    ../components/others/: bsp.c
    ../Libraries/CMSIS_RVMDK/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group sfud
    ../../../sfud/src/: sfud.c sfud_sfdp.c
    ../components/sfud/port/: sfud_port.c
  group std_periph_driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
  group cmsis
    ../Libraries/CMSIS_RVMDK/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
software components: CMSIS:CORE 5.2.0
